# Keil uVision project 10.2秒表（定时器扫描按键数码管）.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 10.2秒表（定时器扫描按键数码管） +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c AT24C02.c AT24C02.h delay.c delay.h I2C.c I2C.h Key.c Key.h nixie.c nixie.h Timer0.c Timer0.h
