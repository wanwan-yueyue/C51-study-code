# Keil uVision project 10.1AT24C02数据存储.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 10.1AT24C02数据存储 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.c LCD1602.h AT24C02.c AT24C02.h I2C.c I2C.h
    ../模块/: delay.c delay.h Key.c Key.h
